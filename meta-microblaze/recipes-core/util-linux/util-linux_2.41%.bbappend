FILESEXTRAPATHS:append:microblaze := ":${THISDIR}/util-linux-2.41"
SRC_URI:append:microblaze = " file://util-linux-microblaze.patch"
