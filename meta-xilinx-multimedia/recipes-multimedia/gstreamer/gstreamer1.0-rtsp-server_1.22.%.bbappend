require gstreamer-xilinx-1.22.%.inc

S = "${UNPACKDIR}/${BP}/subprojects/gst-rtsp-server"
